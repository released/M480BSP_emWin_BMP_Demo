# Keil uVision project Template.uvproj, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc;..\..\Template;..\tslib;..\..\..\ThirdParty\emWin\Config;..\..\..\ThirdParty\emWin\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c timer.c eadc.c ebi.c fmc.c sdh.c
  group User
    ../: main.c misc_config.c
  group emWin
    ../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c LCDConf.c
    ../../../ThirdParty/emWin/Lib/: NUemWin_CM4_Keil.lib
  group tslib
    ../tslib/: diskio.c M48XTouchPanel.c SDGlue.c ts_calibrate.c
  group FatFs
    ../../../ThirdParty/FatFs/source/: ff.c
  group bmp
    ../bmp/: main_240_64.c P1_240_64.c P2_240_64.c P3_240_64.c P4_240_64.c P5_240_64.c P6_240_64.c
  group bmp_raw
    ../bmp/raw/: main_240_64_raw.c P1_240_64_raw.c P2_240_64_raw.c P3_240_64_raw.c P4_240_64_raw.c P5_240_64_raw.c P6_240_64_raw.c
